0010°	TITLE FTALOD - LOAD FROM THE FAST TAPES
0020°	
0030°	R=1		;RELOCATION REGISTER.
0040°	AC2=2		;HOLDS BASE ADDRESS FOR CURRENT CHANNEL.
0050°	AC3=3		;STATUS FLAG MASK FOR CURRENT CHANNEL.
0060°	AC4=4		;ERROR CODE FOR LIGHTS WHEN FATAL CONDITION.
0070°	AC5=5		;POINTER TO CONI'S, ETC. FOR THE CURRENT SA10.
0080°	TACMEM=10	;USED BY FTBOOT, FOR MEM ERR FLAG.
0090°	TACCHL=11	;HOLDS CURRENT CHN NUMBER.
0100°	TAC1=12
0110°	TAC2=13
0120°	TAC3=14
0130°	P=17
0140°	
0150°	SAX1=274
0160°	SAX2=400
0170°	BASE=300
0180°	
0190°	SELERR=(BYTE (8)40)
0200°	BUSIN=(BYTE (8)20)
0210°	CNTLER=(BYTE (8)10)
0220°	LENERR=(BYTE (8)2)
0222µ	STAMOD=(BYTE (8)0,100)
0225°	BUSY=(BYTE (8)0,20)
0230°	UNITCK=(BYTE (8)0,2)
0240°	UNITEX=(BYTE (8)0,1)
0250°	
0260°	MEMERR=600000
0270°	
0280°	CMDREJ=(BYTE (8)200)
0290°	INTREQ=(BYTE (8)100)
0300°	BUSOUT=(BYTE (8)40)
0310°	EQPCHK=(BYTE (8)20)
0320°	DATACK=(BYTE (8)10)
0330°	OVERRN=(BYTE (8)4)
0340°	
0350°	NOTCPB=(BYTE (8)0,1)
0360°	
0370°	MODE7=200000	;MODE FOR 7 TRACK.
0380°	MODE9=220000	;MODE FOR 9 TRACK.
0390°	
0400°	TIC=200000	;TRANSFER IN CHANNEL.
     

0010°	RIM10
0020°	
0030°	IOWD LDSIZ,1
0040°	
0050°	PHASE 1
0060°	
0070°		CONO	APR,100		;CLEAR NXM.
0080°		HRROI	R,0
0090°	NXMCHK:	ADDI	R,2000
0100°		MOVE	0,(R)
0110°		CONSO	APR,100		;NXM?
0120°		JUMPL	R,NXMCHK	;NO, AND NOT END OF CORE.
0130°		CONSO	PTR,10		;WAIT FOR READER DONE.
0140°		JRST	.-1
0150°		DATAI	PTR,AC2		;GET SIZE OF NEXT LOADER.
0160°		HRRI	AC2,-4000+140(R) ;PLACE TO PUT IT (ALLOW 2K).
0170°	TAPLOD:	CONSO	PTR,10
0180°		JRST	.-1
0190°		DATAI	PTR,(AC2)
0200°		AOBJN	AC2,TAPLOD
0210°		JRST	-4000+140(R)	;START NEXT LOADER.
0220°		JRST	1		;START WORD
0230°	
0240°	LDSIZ==.-1
     

0010°		XWD -BLSIZ,0	;FOR AOBJN WD. TO READ FT LOADER.
0020°	
0030°	PHASE 140
0040°	
0050°		SUBI	R,4000		;SET UP
0060°		HRRZS	R		;RELOCATION REGISTER.
0070°		CONO	APR,200000	;CLEAR ALL IO DEVICES.
0080°		CONO	PI,011577	;TURN OFF PI SYSTEM.
0090°		MOVE	P,PDL(R)	;SET UP
0100°		ADDI	P,(R)		;PUSHDOWN LIST.
0110°		MOVE	AC5,R		;AC5=POINTER TO CONI'S, ETC.
0140°		HRRZ	TAC1,CMDAJ1(R)	;RELOCATE
0150°		ADD	TAC1,R		;THE
0160°		HRRM	TAC1,CMDAJ1(R)	;THREE
0170°		HRRZ	TAC1,CMDAJ2(R)	;DATA
0180°		ADD	TAC1,R		;WORDS
0190°		HRRM	TAC1,CMDAJ2(R)	;IN
0195°		HRRZ	TAC1,CMDAJ0(R)	;THE 
0197µ		ADD	TAC1,R		;CMD
0198·		HRRM	TAC1,CMDAJ0(R)	;LISTS.
0200°	
0210°	    ;SEE WHICH UNIT IS SPECIFIED.
0220°		DATAI	APR,TAC1	;READ CONSOLE SWITCHES.
0230°		HLRE	TAC2,TAC1	;LEGAL IS LH=-1,RH=0 TO 7.
0240°		AOJN	TAC2,LOKSA(R)	;JUMP ON FTA0.
0250°		HRRZI	TAC1,(TAC1)	;GET RH.
0260°		CAILE	TAC1,7		;JUMP ON
0270°		JRST	LOKSA(R)	;FTA0.
0280°		MOVEI	TAC2,ADJLST(R)	;SET
0290°	ADJ2:	HRRZ	TAC3,(TAC2)	;UP THE
0300°		ADDI	TAC3,(R)	;DEV ADDR
0310°		DPB	TAC1,[POINT 3,(TAC3),23](R) ;IN
0320°		CAIE	TAC2,ADJEND(R)	;THE
0330°		AOJA	TAC2,ADJ2(R)	;CMDS.
0340°	
0350°	    ;LOOK FOR AN SA10.
0360°	LOKSA:	XCT	CNI(AC5)	;CONI SAXN,TAC1.
0370°		JUMPN	TAC1,LOKCHN(R)	;FOUND AN SA10
0380°	LOKSA1:	ADDI	AC5,1		;TRY NEXT SA10
0390°		MOVEI	TAC1,20
0400°		ADDM	TAC1,BASEA(R)	;SET BASE ADDRESS FOR NEXT SA10
0410°		CAIE	AC5,2(R)	;ASSUME ONLY 2 SA 10'S
0420°		JRST	LOKSA(R)	;NOT DONE SO TRY NEXT SA10
0430°		MOVEI	AC4,1		;ERROR CODE.
0440°		JRST	ERROR(R)	;GO DIE.
     

0010°	    ;LOOK FOR A CHANNEL.
0020°	LOKCHN:	SETZ	TACCHL,		;CHN 0.
0030°		DPB	TACCHL,[POINT 2,STSTRQ(AC5),32](R) ;
0040°		MOVEI	AC3,1B29	;STATUS FLAG FOR CHAN 0
0050°	LOKCH1:	MOVEI	TAC1,^D100000	;LOOP COUNTER
0060°		XCT	STSTRQ(AC5)	;SET STAT REQ FLG.
0070°		XCT	CNSO(AC5)	;CONSO SAXN,(AC3). STAT STORED?
0080°		SOJG	TAC1,.-1(R)	;WAIT A WHILE
0090°		JUMPG	TAC1,LOKDEV(R)	;BUT NOT TOO LONG A WHILE
0100°	    ;HERE ON LOOK AT NEXT CHANNEL.
0110°	LOKCH2:	AOJ	TACCHL,.+1(R)	;UPDATE THE CHN NO.
0120°		LSH	AC3,-1		;AC3=STATUS FLAG FOR NEXT CHN.
0130°		TRNE	AC3,1B33	;LAST CHANNEL?
0140°		JRST	LOKSA1(R)	;YES. TRY NEXT SA10
0150°		DPB	TACCHL,[POINT 2,STSTRQ(AC5),32](R) ;ADJ STSTRQ.
0160°		JRST	LOKCH1(R)	;TRY NEXT CHANNEL.
0170°	    ;LOOK FOR A DEVICE.
0180°	LOKDEV:	MOVEI	AC2,(TACCHL)	;SET UP
0190°		LSH	AC2,2		;THE BASE ADDR FOR
0200°		ADD	AC2,BASEA(R)	;THIS CHANNEL.
0200µ		MOVEI	TAC1,20		;TRY 20
0201°		MOVEM	TAC1,COUNT(R)	;TIMES.
0210°	LOKDV4:	HRRZI	TAC1,CMDSNS(R)	;TIC
0215°		HRLI	TAC1,TIC	;TO
0220°		MOVEM	TAC1,(AC2)	;SENSE.
0230°		PUSHJ	P,STRTI0(R)	;SENSE DEVICE.
0232µ		JRST	.+2(R)		;LOST THIS TIME.
0233·		JRST	LOKDV6(R)	;WON.
0235°		SOSG	COUNT(R)	;OUT OF RETRIES?
0240°		JRST	LOKCH2(R)	;YES, NOT ON THIS CHN, TRY NEXT CHN.
0245°		JRST	LOKDV4(R)	;TRY AGAIN.
0250°	LOKDV6:	LDB	TAC1,[POINT 2,CMDSTS(R),10](R) ;KONT HERE.  DEV
0260°		CAIN	TAC1,2		;IS HERE IF TUA&B
0270°		JRST	UTFND(R)	;=2.
0280°		MOVEI	AC4,2		;ERROR CODE.
0290°		JRST	ERROR(R)	;GO DIE.
0300°	
0310°	    ;FOUND THE DEVICE.
0320°	UTFND:	LDB	TAC1,[POINT 1,CMDSTS(R),11](R) ;7 TRACK UNIT?
0330°		JUMPN	TAC1,.+2(R)	;JUMP ON YES.
0340°		SKIPA	TAC1,[XWD MODE9,0](R) ;9 TRACK MODE.
0350°		MOVSI	TAC1,MODE7	;7 TRACK MODE.
0360°		IORM	TAC1,CMDRED+1(R) ;SET MODE IN THE READ CMD.
     

0010°	    ;REWIND THE TAPE.
0020°		MOVEI	TAC2,^D10	;RETRY COUNT FOR
0030°		MOVEM	TAC2,COUNT(R)	;REW AND SKIP OVER MAGRIM.
0040°	REW1:	HRRZI	TAC1,CMDREW(R)	;POINT TO
0050°		HRRM	TAC1,(AC2)	;REWIND.
0060°		PUSHJ	P,STRWSF(R)	;GO.
0070°		JRST	.+2(R)		;LOST.
0080°		JRST	SKPFL(R)	;WON, GO TO SKIP FILE.
0090°		SOSLE	COUNT(R)	;OUT OF RETRIES?
0100°		JRST	REW1(R)		;NO, TRY AGAIN.
0110°		MOVEI	AC4,3		;YES, GO
0120°		JRST	ERROR(R)	;DIE.
0130°	
0140°	    ;SKIP OVER MAGRIM.
0150°	SKPFL:	HRRZI	TAC1,CMDSKF(R)	;POINT TO
0160°		HRRM	TAC1,(AC2)	;SKIP FILE.
0170°		PUSHJ	P,STRWSF(R)	;GO.
0180°		JRST	.+2(R)		;LOST.
0190°		JRST	FTBOOT(R)	;WON.
0200°		SOSLE	COUNT(R)	;RETRIES LEFT?
0210°		JRST	REW1(R)		;YES.
0220°		MOVEI	AC4,4		;NO, GO
0230°		JRST	ERROR(R)	;DIE.
     

0010°	FTBOOT:	SETZM	20		;CLEAR
0020°		MOVE	TAC1,[XWD 20,21](R) ;MOST OF
0030°		BLT	TAC1,FTBOOT(R)	;CORE.
0040°		PUSHJ	P,READBK(R)	;READ 1ST BLOCK.
0050°		SKIPE	LENEND(R)	;OKAY IF NO LENERR.
0060°		JRST	ERROR5(R)	;CANNOT BE EOF OR LENERR HERE.
0070°		HRRZI	TAC1,CMDBLK(R)	;PNTR TO
0080°		HRLI	TAC1,-200	;DATA AREA.
0090°	
0100°	EXPND0:	PUSHJ	P,RWORD(R)	;GET -N,,LOC OR JRST WORD.
0110°		SKIPL	TAC3,TAC2	;JRST WORD?
0120°		JRST	GO(R)		;YES.
0130°	EXPND:	PUSHJ	P,RWORD(R)	;EXPAND.
0140°		MOVEM	TAC2,1(TAC3)	;STORE WORD.
0150°		AOBJN	TAC3,EXPND(R)	;ADJUST CORE PNTR.
0160°		JRST	EXPND0(R)	;CONTINUE.
0170°	
0180°	RWORD0:	SKIPN	TAC1,LENEND(R)	;PNTR
0190°		HRLZI	TAC1,-200	;TO
0200°		HRRI	TAC1,CMDBLK(R)	;DATA AREA.
0210°	RWORD:	JUMPGE	TAC1,RWNXT(R)	;JUMP ON NEED A BLOCK.
0220°		MOVE	TAC2,(TAC1)	;GET THE WORD.
0230°		AOBJN	TAC1,.+1(R)	;ADJUST PNTR TO DATA AREA.
0240°		POPJ	P,		;RETURN.
0250°	RWNXT:	SKIPE	LENEND(R)	;DONE (LENERR)?
0260°		JRST	ERROR5(R)	;YES.
0270°		PUSHJ	P,READBK(R)	;READ A BLOCK.
0280°		JRST	RWORD0(R)	;OKAY.
0290°		JRST	ERROR5(R)	;SHOULD NEVER SEE EOF.
0300°	
0310°	GO:	PUSHJ	P,READBK(R)	;READ PAST THE
0320°		JRST	.-1(R)		;MONITOR EOF.
0330°		CONO	APR,200000	;CLEAR ALL IO DEVICES.
0340°		JRST	(TAC3)		;START MONITOR.
     

0010°	    ;SUBROUTINE TO EXECUTE A SEQUENCE OF COMMANDS.
0020°	    ;
0030°	    ;USES AC2,AC3, AND AC5.
0040°	    ;DESTROYS TAC1.
0050°	STRTI0:	DPB	TACCHL,[POINT 2,CHNGO(AC5),32](R) ;PUT CHN NO. IN
0060°		DPB	TACCHL,[POINT 2,CHNCLR(AC5),32](R) ;CHNGO & CHNCLR.
0070°	STRTIT: XCT	CHNCLR(AC5)	;CLEAR.
0080°	STRTI2:	MOVEI	TAC1,^D100000	;TIME OUT LOOP
0090°	STRTI3:	XCT	CHNGO(AC5)	;GO.
0100°		XCT	CNSO(AC5)	;WAIT FOR STATUS STORED
0110°		SOJG	TAC1,.-1(R)
0120°		JUMPE	TAC1,STRT4(R)	;TIMED OUT
0130°		MOVE	TAC1,1(AC2)	;ANY ERRS (EXCEPT LENERR OR
0140°		TLNN	TAC1,SELERR!BUSIN!CNTLER!BUSY!UNITCK ;UNITEX)?
0150°		AOS	(P)		;NO.  SKIP RETURN.
0160°		TLNE	TAC1,BUSY	;IF CU BUSY,
0170°		TLNN	TAC1,STAMOD	;THEN WAIT FOR CUEND.
0180°	STRT4:	POPJ	P,		;RETURN.
0190°		XCT	CHNCLR(AC5)	;SAW CU BUSY.  CLEAR.
0190²		MOVEI	TAC1,^D100000	;WAIT FOR
0190´		XCT	CNSO(AC5)	;CUEND.
0190¶		SOJG	TAC1,.-1(R)	;IN ANY CASE, ERROR RETURN.
0190¸		POPJ	P,		;
0200°	
0210°	
0220°	STRWSF:	MOVE	TAC1,[^D20000000](R) ;ALLOW 70 SECONDS FOR
0230°		XCT	CHNCLR(AC5)	;A FULL REWIND OR
0240°		JRST	STRTI3(R)	;SKIP FILE.
0250°	
0260°	
0270°	
0280°	;HERE ON A FATAL CONDITION.
0290°	
0300°	ERROR5:	SKIPA	AC4,[XWD 0,5](R)
0310°	ERROR6:	MOVEI	AC4,6		;ENTER HERE ON ERROR READING TAPE.
0320°	ERROR:	MOVEI	TAC2,(AC4)	S.
0330°		MOVEI	TAC1,207	;BELL CODE.
0340°	ERROR0:	DATAO	TTY,TAC1	;OUT.
0350°		CONSO	TTY,10		;WAIT FOR
0360°		JRST	.-1(R)		;IDLE.
0370°		SOJG	TAC2,ERROR0(R)	;NEXT BELL.
0380°		DATAO	PI,AC4		;DISPLAY ERROR CODE IN LIGHTS.
0390°		HALT	.(R)
0400°	ERROR7:	MOVEI	AC4,7
0410°		JRST	ERROR(R)
     

0010°	;SUBROUTINE TO READ A BLOCK AND DO A LITTLE ERROR PROCESSING.
0020°	;
0030°	;SKIP RETURNS ON EOF, NORMAL RETURNS ON READ OKAY AND NO
0040°	;ERRORS, GOES TO ERROR IF ERRORS.
0050°	;
0060°	;USES AC2 AND AC5.
0070°	;DESTROYS TACFLG,TACMEM,TAC1, AND TAC2.
0080°	
0090°	READBK:	MOVEI	TAC1,^D10	;SET UP RETRY
0100°		MOVEM	TAC1,COUNT(R)	;COUNT.
0110°	READB1:	HRRZI	TAC1,CMDRED(R)	;POINT TO SM
0120°	READB2:	HRRM	TAC1,(AC2)	;CMD.
0130°	READGO:	PUSHJ	P,STRTIT(R)	;GO.
0140°		JRST	READG2(R)	;LOST.
0144°		TLNN	TAC1,UNITEX	;WON.  EOF?
0145°		JRST	.+3(R)		;NO.
0146°		AOS	(P)		;YES.
0148°		POPJ	P,		;RETURN.
0150°		TLNN	TAC1,LENERR	;LENGTH ERROR?
0160°		POPJ	P,		;NO.
0170°		LDB	TAC2,[POINT 11,2(AC2),11](R) ;YES, GET COUNT.
0180°		JUMPE	TAC2,.+2(R)	;MAKE A CORRECT
0190°		TDO	TAC2,[XWD 777777,774000](R) ;NUMBER.
0200°		ADDI	TAC2,200	;STORE THE NEGATIVE OF
0210°		MOVNI	TAC2,(TAC2)	;THE NUMBER OF WORDS TRANSFERRED
0220°		HRLZM	TAC2,LENEND(R)	;IH LH(LENEND).
0225°		POPJ	P,
0260°	READG2:	SOSGE	COUNT(R)	;COUNT=COUNT-1.
0270°		JRST	ERROR6(R)	;OUT OF RETRIES.
0280°		XCT	CNI(AC5) 	;CONI SAXN,TAC1.
0290°		SETZ	TACMEM,		;MEM
0300°		TLNN	TAC1,MEMERR	;ERR?
0310°		JRST	READG4(R)	;NO.
0320°		DPB	TACCHL,[POINT 2,CHCLME(AC5),32](R) ;YES,
0330°		XCT	CHCLME(AC5)	;CLEAR IT.
0340°		SETO	TACMEM,		;FLAG IT.
0345°	READG4:	MOVE	TAC1,1(AC2)	;RESTORE STATUS.
0350°		TLNN	TAC1,UNITCK	;UNIT CHECK?
0360°		JRST	READG5(R)	;NO.
0370°		MOVEM	TAC1,SAVSTS(R)	;YES.  SAVE
0380°		MOVE	TAC1,2(AC2)	;THE 2
0390°		MOVEM	TAC1,SAVST1(R)	;STATUS WORDS.
0400°		HRRZI	TAC1,CMDSNS(R)	;POINT TO THE
0410°		HRRM	TAC1,(AC2)	;SENSE CMD.
0430°		XCT	CHNCLR(AC5)	;CLR THE STATUS FLAG.
0440°		PUSHJ	P,STRTI2(R)	;GO.
0450°		JRST	ERROR6(R)	;DIED ON SENSE.
0460°		MOVE	TAC1,SAVST1(R)	;RESTORE
0470°		MOVEM	TAC1,2(AC2)	;THE
0480°		MOVE	TAC1,SAVSTS(R)	;STATUS.
0490°	READG5:	JUMPL	TACMEM,REDPOS(R) ;JUMP ON MEM ERR.
0500°		TLNE	TAC1,SELERR!BUSIN!CNTLER ;THESE ERRS?
0510°		JRST	ERROR6(R)	;YES,DIE.
0520°		MOVE	TAC1,CMDSTS(R)	;NO. GET SENSE BYTE 0.
0530°		TLNE	TAC1,EQPCHK	;EQUIP CHECK?
0540°		JRST	ERROR6(R)	;YES.
0550°		TLNN	TAC1,BUSOUT	;NO, BUS OUT?;
0560°		JRST	READG8(R)	;NO.
0570°		HRRZ	TAC1,2(AC2)	;YES, POINT TO
0580°		SOJ	TAC1,.+1(R)	;PREVIOUS CMD AND THEN
0590°		JRST	READB2(R)	;GO.
0600°	READG8:	TLNE	TAC1,INTREQ!CMDREJ ;INT REQ OR CMD REJECT?
0605°		JRST	ERROR6(R)	;YES.
0610°		TLNE	TAC1,OVERRN!DATACK ;NO, OVRN OR DATA CHECK?
0615°		JRST	READG9(R)	;YES.
0620°		LDB TAC1,[POINT 1,CMDSTS(R),15](R) ;NO.
0630°		TLNE TAC1,NOTCPB	;NOT CAPABLE?
0640°		JRST	ERROR7(R)	;YES.
0650°		JRST	ERROR6(R)	;NO, OTHER FATAL ERR.
0660°	READG9:	TLNN	TAC1,DATACK	;DATA CHECK?
0670°		JRST	REDPOS(R)	;NO.
0680°		LDB	TAC1,[POINT 11,2(AC2),11](R) ;YES, WORRY ABOUT
0690°		JUMPE	TAC1,REDPOS(R)	;POSSIBLE NOISE RECORD.
0700°		TDO	TAC1,[XWD 777777,774000](R) ;MAKE COUNT A NO.
0710°		SUBI	TAC1,200	;GET ITEMS READ.
0720°		CAIG	TAC1,3		;NOISE RECORD?
0730°		JRST	READB1(R)	;YES, NO NEED TO BSR.
0740°	REDPOS:	HRRZI	TAC1,CMDBSR(R)	;HERE ON REPOSITION NEEDED.
0760°		JRST	READB2(R)	;GO.
     

0010°	PDL:	IOWD 10,.+1
0020°		BLOCK 10
0030°	
0060°	CHNGO:	CONO	SAX1,440	;GO.
0070°		CONO	SAX2,440	;"
0080°	CHNCLR: CONO	SAX1,600	;CLEAR THE STATUS FLAG.
0090°		CONO	SAX2,600	;        "
0100°	CHCLME: CONO	SAX1,200000	;CLEAR MEM ERR FOR CHN 0.
0110°		CONO	SAX2,200000	;        "
0120°	STSTRQ: CONO	SAX1,540	;SET STAT REQ FLG.
0130°		CONO	SAX2,540	;        "
0140°	CNI:	CONI	SAX1,TAC1
0150°		CONI	SAX2,TAC1
0160°	CNSO:	CONSO	SAX1,(AC3)	;USED TO LOOK FOR STATUS FLAG.
0170°		CONSO	SAX2,(AC3)	;           "
0180°	
0190°	BASEA:	BASE
0200°	
0240°	CMDSNS:	BYTE (8)70,4,200	;SENSE.
0250°	CMDAJ1:	BYTE (12)-^D24(24)CMDSTS ;DW.
0260°		Z
0270°	
0275°	CMDBSR:	BYTE(8) 260,223,200	;SM.
0280°		BYTE(8)260,47,200	;BSR.
0290°		BYTE(8)071,33,200	;TIE.
0295°	CMDAJ0:	BYTE(12)-1(24)CMDSTS	;DATA WORD.
0300°	CMDRED: BYTE (8)260,223,200	;SM.
0310°		BYTE (8)60,2,200	;READ.
0320°	CMDAJ2:	BYTE (12)-200(24)CMDBLK ;DW.
0330°		Z
0340°	
0350°	CMDREW:	BYTE(8) 260,223,200	;SM.
0360°		BYTE(8) 260,7,200	;REW.
0370°		Z
0380°	
0390°	CMDSKF:	BYTE(8) 260,123,200	;SM.
0400°		BYTE(8) 260,77,200	;SKIPFILE.
0410°		Z
0420°	
0430°	LENEND: Z
0440°	
0450°	ADJLST:	CMDBSR
0460°		CMDBSR+1
0465°		CMDBSR+2
0470°		CMDRED
0480°		CMDRED+1
0490°		CMDSNS
0500°		CMDREW
0510°		CMDREW+1
0520°		CMDSKF
0530°	ADJEND:	CMDSKF+1
0540°	
0550°	LIT
0560°	SAVSTS:
0570°	SAVST1=SAVSTS+1
0580°	COUNT=SAVST1+1
0590°	CMDSTS=COUNT+1
0600°	CMDBLK=CMDSTS+6
0610°	BLSIZ==.-140
0620°		END
@'